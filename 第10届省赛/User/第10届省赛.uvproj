# Keil uVision project 第10届省赛.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第10届省赛_新驱动 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\System;..\Driver;..\Config
  group User
    ./: main.c
  group Driver
    ../Driver/: led.c led.h key.c key.h PCF8591.c PCF8591.h
  group System
    ../System/: iic.c iic.h NE555.c NE555.h
  group Config
    ../Config/: config.h init.c init.h
