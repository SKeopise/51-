# Keil uVision project 13届省赛第二场.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13届省赛第二场 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\System;..\Driver;..\Config
  group User
    ./: main.c
  group Driver
    ../Driver/: key.c key.h led.c led.h Sonic.c Sonic.h
  group System
    ../System/: iic.c iic.h
  group Config
    ../Config/: config.h init.c init.h
