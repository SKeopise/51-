# Keil uVision project 多功能计算器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 密码锁test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include;..\Driver;..\System
  group User
    ./: STARTUP.A51 main.c
    ../Include/: main.h
  group System
    ../System/: stc_int.c stc_i2c.c stc_i2c.h stc_delay.c
    ../Driver/: stc_BUZZ.c
  group Driver
    ../Driver/: stc_key.c stc_LCD1602.c stc_LCD1602.h EEPROM.c EEPROM.h Password.c Password.h
  group Include
    ../Include/: stc_key.h stc_int.h config.h stc_delay.h stc_BUZZ.h
