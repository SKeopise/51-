# Keil uVision project 自动灌溉系统.uvproj, settings and files
target 自动灌溉系统 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 自动灌溉系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include;..\Driver;..\system;..\User
  group User
    ./: main.c main.h
  group System
    ../system/: init.c
    ../Driver/: iic.c ds1302.c
  group Driver
    ../Driver/: Key.c Led.c PCF8951.c EEPROM.c BUZZ.c
  group Include
    ../Include/: config.h Led.h Key.h init.h
    ../Driver/: iic.h ds1302.h EEPROM.h PCF8951.h BUZZ.h
