# Keil uVision project 轮询架构测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 轮询架构测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Include;..\System;..\User
  group User
    ./: main.c
  group System
    ../System/: init.c init.h
  group Driver
    ../Driver/: led.c led.h key.c key.h DS18B20.h DS18B20.c
  group Include
    ../Include/: config.h onewire.c onewire.h ds1302.h ds1302.c
