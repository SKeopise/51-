# Keil uVision project TEXT11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TEXT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\system;..\Driver;..\Include
  group User
    ./: STARTUP.A51 main.c main.h
  group Driver
    ../Driver/: Key.c Led.c PCF8951.c EEPROM.c
  group System
    ../system/: init.c
    ../Driver/: iic.c
  group Include
    ../Include/: Led.h Key.h config.h init.h
    ../Driver/: iic.h PCF8951.h EEPROM.h
