# Keil uVision project 第13届国赛.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第13届国赛01 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Driver;.\System;.\Config
  group User
    ./User/: main.c
  group Driver
    ./Driver/: key.c key.h led.c led.h NE555.c NE555.h sonic.c sonic.h
  group System
    ./System/: iic.c iic.h EEPROM.c EEPROM.h PCF8591.c PCF8591.h
  group Config
    ./Config/: config.h init.c init.h
