# Keil uVision project 蓝桥杯国赛test3.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 蓝桥杯国赛test3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\System;..\Driver;..\Config
  group User
    ./: main.c
  group Driver
    ../Driver/: led.c led.h key.c key.h EEPROM.c EEPROM.h sonic.c sonic.h
  group System
    ../System/: ds1302.c ds1302.h iic.c iic.h
  group Config
    ../Config/: config.h init.c init.h
