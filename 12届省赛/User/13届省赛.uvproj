# Keil uVision project 13届省赛.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 12届省赛 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Config;..\System;..\User
  group User
    ./: main.c
  group Drive
    ../Driver/: Led.c Led.h key.c key.h
  group System
    ../System/: onewire.c onewire.h iic.c iic.h
  group Config
    ../Config/: config.h init.c init.h
