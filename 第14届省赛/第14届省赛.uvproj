# Keil uVision project 第14届省赛.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第14届省赛 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Config;.\Driver;.\System
  group User
    ./User/: main.c
  group Driver
    ./Driver/: key.c key.h led.c led.h NE555.c NE555.h PCF8591.c PCF8591.h
  group System
    ./System/: ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h
  group Config
    ./Config/: config.h init.c init.h
