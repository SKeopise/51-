# Keil uVision project 多功能计算器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 多功能计算器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include;..\Driver;..\System
  group User
    ./: STARTUP.A51 main.c
    ../Include/: main.h
  group System
    ../System/: stc_int.c stc_delay.c
  group Driver
    ../Driver/: stc_key.c stc_Led.c stc_28BYJ48.c stc_BUZZ.c stc_Snake.c
  group Include
    ../Include/: stc_Led.h stc_key.h stc_int.h stc_delay.h config.h stc_28BYJ48.h stc_BUZZ.h stc_Snake.h
